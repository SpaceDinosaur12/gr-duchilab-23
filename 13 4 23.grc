options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: bpsk_stage6
    output_language: python
    title: bpsk_stage6
  states: {}

blocks:
- name: LPF_cutoff
  id: variable
  parameters:
    value: bit_rate / 2
  states: {}
- name: arity
  id: variable
  parameters:
    value: '2'
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: 1e6
  states: {state: disabled}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: bw
  id: variable
  parameters:
    value: 15e3
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '29'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 436e6
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3*3
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / bit_rate)
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: time_offset
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/hsl/Documents/tx_debug_march
    type: byte
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '8'
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 0, 1, 0, 0, 0, 0, 0)
  states: {}
- name: ccsds_ccsds_decoder_0
  id: ccsds_ccsds_decoder
  parameters:
    deinterleave: 'False'
    descramble: 'False'
    dual_basis: 'False'
    n_deinterleave: '5'
    printing: 'True'
    rs_decode: 'False'
    threshold: '0'
    verbose: 'False'
  states: {}
- name: ccsds_ccsds_encoder_0
  id: ccsds_ccsds_encoder
  parameters:
    dual_basis: 'False'
    interleave: 'False'
    len_tag_key: '"packet_len"'
    n_interleave: '5'
    printing: 'False'
    rs_encode: 'False'
    scramble: 'False'
    type: byte
    verbose: 'False'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    comment: Add RRC!
    constellation: bpsk
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 48e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '960'
    win: window.WIN_HAMMING
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '2000'
    minsize: '50'
  states: {state: disabled}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 48e3
    fftsize: '1024'
    gui_hint: 0,1,2,1
    name: '"Sym_GUI"'
    type: complex
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,2,1
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 2,0,2,1
    label1: Rx Bits
    label2: Diff
    label3: Tx Bits
    name: ''
    nconnections: '3'
    size: '512'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: satellites_rms_agc_0_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: soapy_limesdr_source_1
  id: soapy_limesdr_source
  parameters:
    bandwidth: bw
    center_freq: freq
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 1e6
    center_freq0: freq
    gain0: '40'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '"xmt_sig"'
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '"xmt_sig"'
  states: {state: disabled}

connections:
- [blocks_char_to_float_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_float_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [blocks_stream_to_tagged_stream_0, '0', ccsds_ccsds_encoder_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_0, '0', virtual_sink_1, '0']
- [ccsds_ccsds_encoder_0, '0', digital_constellation_modulator_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', ccsds_ccsds_decoder_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0_0, '0', uhd_usrp_sink_1, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_float_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_sink_x_1_0, '0']
- [digital_diff_decoder_bb_0, '0', ccsds_ccsds_decoder_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_costas_loop_cc_0, '0']
- [low_pass_filter_1, '0', satellites_rms_agc_0_0, '0']
- [pdu_random_pdu_0, pdus, ccsds_ccsds_encoder_0, '0']
- [satellites_rms_agc_0_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [soapy_limesdr_source_1, '0', low_pass_filter_1, '0']
- [soapy_limesdr_source_1, '0', qtgui_sink_x_2, '0']
- [virtual_source_1, '0', blocks_file_sink_0_0, '0']
- [virtual_source_1, '0', blocks_unpack_k_bits_bb_0_0, '0']

metadata:
  file_format: 1
