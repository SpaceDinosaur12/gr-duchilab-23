options:
  parameters:
    author: Ido
    category: '[HSL]/Modulators'
    generate_options: qt_gui
    id: afsk
    output_language: python
    title: AFSK AX.25 Mod
  states: {}

blocks:
- name: center
  id: variable
  parameters:
    value: int((mark_freq + space_freq)/2)
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.5'
    gain: '1.0'
    ntaps: int(11*sps*16)
    samp_rate: samp_rate
    sym_rate: baud_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baud_rate
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset
    offset: '0'
    phase: '0'
    samp_rate: rf_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    label: Baud Rate
    type: intx
    value: '1200'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '2'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '100'
    minsize: '50'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(sps)
    type: byte
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '.95'
    samp_rate: samp_rate
    sensitivity: 2*math.pi
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[mark_freq, space_freq]'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center
    decim: '1'
    samp_rate: samp_rate
    taps: rrc_taps
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_sink_1
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: '60'
    oversample: '0'
    rf_freq: 435e6
    samp_rate: rf_samp_rate
  states: {}
- name: mark_freq
  id: parameter
  parameters:
    label: Mark Frequency
    type: intx
    value: '1200'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4000'
    type: TCP_SERVER
  states: {}
- name: offset
  id: parameter
  parameters:
    label: Tx Carrier Offset
    type: eng_float
    value: 50e3
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '2000'
    minsize: '50'
  states: {state: disabled}
- name: postamble_len
  id: parameter
  parameters:
    label: Postamble Length (bytes)
    type: eng_float
    value: '4'
  states: {}
- name: preamble_len
  id: parameter
  parameters:
    label: Preamble Length (ms)
    type: eng_float
    value: '.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(rf_samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(rf_samp_rate / samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: rf_samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2.4e6
  states: {}
- name: satellites_afsk_demodulator_0
  id: satellites_afsk_demodulator
  parameters:
    af_carrier: (space_freq - mark_freq)/2 + mark_freq + offset
    baudrate: baud_rate
    deviation: (space_freq - mark_freq)/2
    iq: 'True'
    samp_rate: samp_rate
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'False'
  states: {}
- name: satellites_hdlc_framer_0_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '7'
    preamble_bytes: '50'
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {state: bypassed}
- name: space_freq
  id: parameter
  parameters:
    label: Space Frequency
    type: intx
    value: '2200'
  states: {}

connections:
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [blocks_message_strobe_0_0, strobe, blocks_random_pdu_0, generate]
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', satellites_afsk_demodulator_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', satellites_nrzi_encode_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_random_pdu_0, pdus, satellites_hdlc_framer_0_0, in]
- [blocks_repeat_0, '0', digital_chunks_to_symbols_xx_1, '0']
- [blocks_vco_f_0, '0', analog_nbfm_tx_0, '0']
- [blocks_vco_f_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', blocks_vco_f_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '1']
- [rational_resampler_xxx_0_0, '0', limesdr_sink_1, '0']
- [satellites_afsk_demodulator_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_afsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']
- [satellites_ax25_deframer_0, out, blocks_message_debug_0, print]
- [satellites_hdlc_framer_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_nrzi_encode_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
