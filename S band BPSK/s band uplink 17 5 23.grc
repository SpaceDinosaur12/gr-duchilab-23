options:
  parameters:
    generate_options: qt_gui
    id: v19_4_23_uplink
    output_language: python
    title: 19 4 23 uplink
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {state: disabled}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: filter_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2250e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 436e6
  states: {state: disabled}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.01'
    stop: '1'
    value: '.97'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bit_rate * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '15'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '8'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 0, 1, 0, 0, 0, 0, 0)
  states: {}
- name: ccsds_ccsds_encoder_0
  id: ccsds_ccsds_encoder
  parameters:
    dual_basis: 'False'
    interleave: 'False'
    len_tag_key: '"packet_len"'
    n_interleave: '5'
    printing: 'False'
    rs_encode: 'False'
    scramble: 'False'
    type: byte
    verbose: 'False'
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    comment: Add RRC!
    constellation: bpsk
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: lfast_rrc_filter_0
  id: lfast_rrc_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: filter_gain
    ntaps: '8'
    nthreads: '1'
    samp_rate: samp_rate
    sym_rate: '1.0'
    type: ccc
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '10'
    ntaps: '10'
    samp_rate: samp_rate
    sym_rate: '1.0'
    type: fir_filter_ccf
  states: {state: disabled}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    dev_addr: ''
    gain0: gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0, '0', ccsds_ccsds_encoder_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [ccsds_ccsds_encoder_0, '0', digital_constellation_modulator_0_0, '0']
- [digital_constellation_modulator_0_0, '0', lfast_rrc_filter_0, '0']
- [digital_constellation_modulator_0_0, '0', root_raised_cosine_filter_0, '0']
- [lfast_rrc_filter_0, '0', qtgui_sink_x_0, '0']
- [lfast_rrc_filter_0, '0', uhd_usrp_sink_1, '0']
- [root_raised_cosine_filter_0, '0', uhd_usrp_sink_1, '0']

metadata:
  file_format: 1
