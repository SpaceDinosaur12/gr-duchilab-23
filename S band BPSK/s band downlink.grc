options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: v19_4_23downlink
    output_language: python
    title: 19 4 23 downlink
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '2'
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {state: disabled}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: bw
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: filter_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {state: disabled}
- name: filter_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2250e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 436e6
  states: {state: disabled}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '-12'
    step: '1'
    stop: '61'
    value: '30'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bit_rate * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '15'
  states: {state: disabled}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    start: '0.001'
    step: '0.0001'
    stop: '1'
    value: '0.0628'
  states: {state: disabled}
- name: timing_loop_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {state: disabled}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '0.1'
    value: '0.0628'
  states: {}
- name: ccsds_ccsds_decoder_0
  id: ccsds_ccsds_decoder
  parameters:
    deinterleave: 'False'
    descramble: 'False'
    dual_basis: 'False'
    n_deinterleave: '5'
    printing: 'True'
    rs_decode: 'False'
    threshold: '0'
    verbose: 'False'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: timing_loop_bw
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: lfast_agc_fast_0
  id: lfast_agc_fast
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
  states: {}
- name: lfast_costas2_0
  id: lfast_costas2
  parameters:
    genSignalPDUs: 'False'
    w: timing_loop_bw
  states: {}
- name: lfast_low_pass_filter_0
  id: lfast_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: bit_rate * 2
    decim: '1'
    gain: filter_gain
    nthreads: '1'
    samp_rate: samp_rate
    type: ccc
    width: bit_rate/2
    win: '1'
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 48e3
    decim: '1'
    gain: '10'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '960'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 48e3
    fftsize: '1024'
    gui_hint: 0,1,2,1
    name: '"Sym_GUI"'
    type: complex
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,2,1
    type: complex
  states: {}
- name: satellites_rms_agc_0_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {state: disabled}
- name: soapy_limesdr_source_1
  id: soapy_limesdr_source
  parameters:
    bandwidth: samp_rate
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [digital_constellation_decoder_cb_0, '0', ccsds_ccsds_decoder_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_sink_x_1_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', lfast_costas2_0, '0']
- [lfast_agc_fast_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [lfast_costas2_0, '0', digital_constellation_decoder_cb_0, '0']
- [lfast_costas2_0, '0', qtgui_sink_x_1_0, '0']
- [lfast_low_pass_filter_0, '0', lfast_agc_fast_0, '0']
- [low_pass_filter_1, '0', satellites_rms_agc_0_0, '0']
- [satellites_rms_agc_0_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [soapy_limesdr_source_1, '0', lfast_low_pass_filter_0, '0']
- [soapy_limesdr_source_1, '0', low_pass_filter_1, '0']
- [soapy_limesdr_source_1, '0', qtgui_sink_x_2, '0']

metadata:
  file_format: 1
