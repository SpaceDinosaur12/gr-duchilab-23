options:
  parameters:
    author: rabin
    generate_options: qt_gui
    id: Transceiver_ccsds
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alg
  id: variable_adaptive_algorithm
  parameters:
    cons: constellation
    modulus: '2'
    step_size: '.00001'
    type: cma
  states: {}
- name: alpha
  id: variable
  parameters:
    comment: |-
      Can't change alpha in real time
      for Consteallation Modulator
    value: '0.50'
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: samp_rate / sps
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2245e6
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: freq_shift
  id: variable
  parameters:
    value: 30e3
  states: {}
- name: gain_rx
  id: variable_qtgui_range
  parameters:
    start: '-12'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: gain_tx
  id: variable_qtgui_range
  parameters:
    start: '-12'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    comment: |-
      Gain: nfilts
      Sample Rate: nfilts*samp_rate
      Symbol Rate: samp_rate/sps
      Excess BW: alpha
      Num Taps: 11*sps*nfilts
    gain: nfilts
    ntaps: 11*int(sps*nfilts)
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '20'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-freq_shift'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rabin/Documents/filesink
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Keep the signal from going
      above +1 or below -1
    const: '0.4'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-0.01'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      skip one second of samples
      to allow FLL to sync
    num_items: int(samp_rate)
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '8'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: constellation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: bypassed}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 0, 0, 0, 1, 0, 0, 1)
  states: {}
- name: ccsds_ccsds_decoder_0
  id: ccsds_ccsds_decoder
  parameters:
    deinterleave: 'False'
    descramble: 'False'
    dual_basis: 'False'
    n_deinterleave: '5'
    printing: 'False'
    rs_decode: 'False'
    threshold: '16'
    verbose: 'False'
  states: {}
- name: ccsds_ccsds_encoder_0
  id: ccsds_ccsds_encoder
  parameters:
    dual_basis: 'False'
    interleave: 'False'
    len_tag_key: '"packet_len"'
    n_interleave: '5'
    printing: 'False'
    rs_encode: 'False'
    scramble: 'False'
    type: byte
    verbose: 'False'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: |-
      Unpack bytes into chunks of bits,
      look up constellation symbol,
      and apply RRC filter
    constellation: constellation
    differential: 'False'
    excess_bw: alpha
    samples_per_symbol: int(sps)
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: constellation.arity()
    w: 2*math.pi/100
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    comment: |-
      Samples Per Symbol: sps
      Filter Rolloff Factor: alpha
      Prototype Filter Size: sps*2+1
      Loop Bandwidth: 2*math.pi/sps/100
    filter_size: int(sps*2+1)
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: alg
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x0021'
    seed: '0x00'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Filterbank Arms: nfilts
      PFB MF Taps: rcc_taps
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: nfilts
    osps: '2'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import socket


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self, ip="127.0.0.1", port="9999"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Socket Python Block',  # will show up in GRC
                  in_sig=None,
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.ip = ip
              self.port = port
              self.b = False
              self.my_socket = socket.socket()

          def work(self, input_items, output_items):
              if not self.b:
                  self.my_socket.connect(("127.0.0.1", 9999))
                  self.b = True
              
              msg = self.my_socket.recv(1)

              output_items[0][:] = msg
              return len(output_items[0])
    ip: '"127.0.0.1"'
    port: '9999'
  states: {state: disabled}
- name: fec_decode_ccsds_27_fb_0
  id: fec_decode_ccsds_27_fb
  parameters: {}
  states: {state: disabled}
- name: fec_encode_ccsds_27_bb_0
  id: fec_encode_ccsds_27_bb
  parameters: {}
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bit_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: bit_rate / 6
    win: window.WIN_HAMMING
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,2,2,2
    name: '"post_equalizer"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,2,2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Decoded"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,4
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {state: disabled}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {state: disabled}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '0.5'
    reference: '1.0'
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    bandwidth: samp_rate
    center_freq: center_freq
    gain: gain_tx
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: samp_rate
    center_freq: center_freq - freq_shift
    gain: gain_rx
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_char_to_float_1, '0', fec_decode_ccsds_27_fb_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_limesdr_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', ccsds_ccsds_encoder_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', fec_encode_ccsds_27_bb_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [ccsds_ccsds_decoder_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [ccsds_ccsds_encoder_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [ccsds_ccsds_encoder_0, '0', digital_scrambler_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_1, '0']
- [digital_constellation_decoder_cb_0, '0', ccsds_ccsds_decoder_0, '0']
- [digital_constellation_decoder_cb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_costas_loop_cc_0, '0', digital_linear_equalizer_0, '0']
- [digital_descrambler_bb_0, '0', ccsds_ccsds_decoder_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_linear_equalizer_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0, '0']
- [digital_scrambler_bb_0, '0', satellites_nrzi_encode_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [fec_decode_ccsds_27_fb_0, '0', blocks_char_to_float_0, '0']
- [fec_decode_ccsds_27_fb_0, '0', blocks_file_sink_0, '0']
- [fec_encode_ccsds_27_bb_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', satellites_rms_agc_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_char_to_float_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0, '0']
- [satellites_nrzi_encode_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [satellites_rms_agc_0, '0', digital_fll_band_edge_cc_0, '0']
- [soapy_limesdr_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
