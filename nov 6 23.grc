options:
  parameters:
    author: rabin
    generate_options: qt_gui
    id: nov623
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import socket


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self, ip="127.0.0.1", port="9999"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Socket Python Block',  # will show up in GRC
                  in_sig=None,
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.ip = ip
              self.port = port
              self.b = False
              self.my_socket = socket.socket()

          def work(self, input_items, output_items):
              if not self.b:
                  self.my_socket.connect(("127.0.0.1", 9999))
                  self.b = True
              
              msg = int(self.my_socket.recv(1).decode())

              output_items[0][:] = msg
              return len(output_items[0])
    ip: '"127.0.0.1"'
    port: '9999'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
